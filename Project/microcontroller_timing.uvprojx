# Keil uVision project microcontroller_timing.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: microcontroller_timing
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./: main.c asciiLib.c displayctrl.c LCD_ILI9325.c systemFunctions.c utility.c firstTrafficLightsWithThreeColors.c messageBrockerThread.c secondTrafficLightsWithThreeColors.c inputThreads.c thirdTrafficLightsWithThreeColors.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:STM32Cube LL:COMMON 1.11.3, Device:STM32Cube LL:CRC 1.11.3, Device:STM32Cube LL:GPIO 1.11.3, Device:STM32Cube LL:PWR 1.11.3, Device:STM32Cube LL:RCC 1.11.3, Device:STM32Cube LL:RTC 1.11.3, Device:STM32Cube LL:UTILS 1.11.3, Device:Startup 1.11.3
